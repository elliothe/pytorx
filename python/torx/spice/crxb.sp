** Generate for: hspice
** crosbar size is 16
** vdd is 3.3
.OP

v0 input0 0 DC=3.3
rin0 input0 top0p0 1.0
v1 input1 0 DC=3.3
rin1 input1 top1p0 1.0
v2 input2 0 DC=3.3
rin2 input2 top2p0 1.0
v3 input3 0 DC=3.3
rin3 input3 top3p0 1.0
v4 input4 0 DC=3.3
rin4 input4 top4p0 1.0
v5 input5 0 DC=3.3
rin5 input5 top5p0 1.0
v6 input6 0 DC=3.3
rin6 input6 top6p0 1.0
v7 input7 0 DC=3.3
rin7 input7 top7p0 1.0
v8 input8 0 DC=3.3
rin8 input8 top8p0 1.0
v9 input9 0 DC=3.3
rin9 input9 top9p0 1.0
v10 input10 0 DC=3.3
rin10 input10 top10p0 1.0
v11 input11 0 DC=3.3
rin11 input11 top11p0 1.0
v12 input12 0 DC=3.3
rin12 input12 top12p0 1.0
v13 input13 0 DC=3.3
rin13 input13 top13p0 1.0
v14 input14 0 DC=3.3
rin14 input14 top14p0 1.0
v15 input15 0 DC=3.3
rin15 input15 top15p0 1.0
r0p0 top0p0 bot0p0 2.0
rrow0p1 top0p0 top0p1 1.0
r0p1 top0p1 bot0p1 2.0
rrow0p2 top0p1 top0p2 1.0
r0p2 top0p2 bot0p2 2.0
rrow0p3 top0p2 top0p3 1.0
r0p3 top0p3 bot0p3 2.0
rrow0p4 top0p3 top0p4 1.0
r0p4 top0p4 bot0p4 2.0
rrow0p5 top0p4 top0p5 1.0
r0p5 top0p5 bot0p5 2.0
rrow0p6 top0p5 top0p6 1.0
r0p6 top0p6 bot0p6 2.0
rrow0p7 top0p6 top0p7 1.0
r0p7 top0p7 bot0p7 2.0
rrow0p8 top0p7 top0p8 1.0
r0p8 top0p8 bot0p8 2.0
rrow0p9 top0p8 top0p9 1.0
r0p9 top0p9 bot0p9 2.0
rrow0p10 top0p9 top0p10 1.0
r0p10 top0p10 bot0p10 2.0
rrow0p11 top0p10 top0p11 1.0
r0p11 top0p11 bot0p11 2.0
rrow0p12 top0p11 top0p12 1.0
r0p12 top0p12 bot0p12 2.0
rrow0p13 top0p12 top0p13 1.0
r0p13 top0p13 bot0p13 2.0
rrow0p14 top0p13 top0p14 1.0
r0p14 top0p14 bot0p14 2.0
rrow0p15 top0p14 top0p15 1.0
r0p15 top0p15 bot0p15 2.0
rcol1p0 bot0p0 bot1p0 1.0
r1p0 top1p0 bot1p0 2.0
rrow1p1 top1p0 top1p1 1.0
rcol1p1 bot0p1 bot1p1 1.0
r1p1 top1p1 bot1p1 2.0
rrow1p2 top1p1 top1p2 1.0
rcol1p2 bot0p2 bot1p2 1.0
r1p2 top1p2 bot1p2 2.0
rrow1p3 top1p2 top1p3 1.0
rcol1p3 bot0p3 bot1p3 1.0
r1p3 top1p3 bot1p3 2.0
rrow1p4 top1p3 top1p4 1.0
rcol1p4 bot0p4 bot1p4 1.0
r1p4 top1p4 bot1p4 2.0
rrow1p5 top1p4 top1p5 1.0
rcol1p5 bot0p5 bot1p5 1.0
r1p5 top1p5 bot1p5 2.0
rrow1p6 top1p5 top1p6 1.0
rcol1p6 bot0p6 bot1p6 1.0
r1p6 top1p6 bot1p6 2.0
rrow1p7 top1p6 top1p7 1.0
rcol1p7 bot0p7 bot1p7 1.0
r1p7 top1p7 bot1p7 2.0
rrow1p8 top1p7 top1p8 1.0
rcol1p8 bot0p8 bot1p8 1.0
r1p8 top1p8 bot1p8 2.0
rrow1p9 top1p8 top1p9 1.0
rcol1p9 bot0p9 bot1p9 1.0
r1p9 top1p9 bot1p9 2.0
rrow1p10 top1p9 top1p10 1.0
rcol1p10 bot0p10 bot1p10 1.0
r1p10 top1p10 bot1p10 2.0
rrow1p11 top1p10 top1p11 1.0
rcol1p11 bot0p11 bot1p11 1.0
r1p11 top1p11 bot1p11 2.0
rrow1p12 top1p11 top1p12 1.0
rcol1p12 bot0p12 bot1p12 1.0
r1p12 top1p12 bot1p12 2.0
rrow1p13 top1p12 top1p13 1.0
rcol1p13 bot0p13 bot1p13 1.0
r1p13 top1p13 bot1p13 2.0
rrow1p14 top1p13 top1p14 1.0
rcol1p14 bot0p14 bot1p14 1.0
r1p14 top1p14 bot1p14 2.0
rrow1p15 top1p14 top1p15 1.0
rcol1p15 bot0p15 bot1p15 1.0
r1p15 top1p15 bot1p15 2.0
rcol2p0 bot1p0 bot2p0 1.0
r2p0 top2p0 bot2p0 2.0
rrow2p1 top2p0 top2p1 1.0
rcol2p1 bot1p1 bot2p1 1.0
r2p1 top2p1 bot2p1 2.0
rrow2p2 top2p1 top2p2 1.0
rcol2p2 bot1p2 bot2p2 1.0
r2p2 top2p2 bot2p2 2.0
rrow2p3 top2p2 top2p3 1.0
rcol2p3 bot1p3 bot2p3 1.0
r2p3 top2p3 bot2p3 2.0
rrow2p4 top2p3 top2p4 1.0
rcol2p4 bot1p4 bot2p4 1.0
r2p4 top2p4 bot2p4 2.0
rrow2p5 top2p4 top2p5 1.0
rcol2p5 bot1p5 bot2p5 1.0
r2p5 top2p5 bot2p5 2.0
rrow2p6 top2p5 top2p6 1.0
rcol2p6 bot1p6 bot2p6 1.0
r2p6 top2p6 bot2p6 2.0
rrow2p7 top2p6 top2p7 1.0
rcol2p7 bot1p7 bot2p7 1.0
r2p7 top2p7 bot2p7 2.0
rrow2p8 top2p7 top2p8 1.0
rcol2p8 bot1p8 bot2p8 1.0
r2p8 top2p8 bot2p8 2.0
rrow2p9 top2p8 top2p9 1.0
rcol2p9 bot1p9 bot2p9 1.0
r2p9 top2p9 bot2p9 2.0
rrow2p10 top2p9 top2p10 1.0
rcol2p10 bot1p10 bot2p10 1.0
r2p10 top2p10 bot2p10 2.0
rrow2p11 top2p10 top2p11 1.0
rcol2p11 bot1p11 bot2p11 1.0
r2p11 top2p11 bot2p11 2.0
rrow2p12 top2p11 top2p12 1.0
rcol2p12 bot1p12 bot2p12 1.0
r2p12 top2p12 bot2p12 2.0
rrow2p13 top2p12 top2p13 1.0
rcol2p13 bot1p13 bot2p13 1.0
r2p13 top2p13 bot2p13 2.0
rrow2p14 top2p13 top2p14 1.0
rcol2p14 bot1p14 bot2p14 1.0
r2p14 top2p14 bot2p14 2.0
rrow2p15 top2p14 top2p15 1.0
rcol2p15 bot1p15 bot2p15 1.0
r2p15 top2p15 bot2p15 2.0
rcol3p0 bot2p0 bot3p0 1.0
r3p0 top3p0 bot3p0 2.0
rrow3p1 top3p0 top3p1 1.0
rcol3p1 bot2p1 bot3p1 1.0
r3p1 top3p1 bot3p1 2.0
rrow3p2 top3p1 top3p2 1.0
rcol3p2 bot2p2 bot3p2 1.0
r3p2 top3p2 bot3p2 2.0
rrow3p3 top3p2 top3p3 1.0
rcol3p3 bot2p3 bot3p3 1.0
r3p3 top3p3 bot3p3 2.0
rrow3p4 top3p3 top3p4 1.0
rcol3p4 bot2p4 bot3p4 1.0
r3p4 top3p4 bot3p4 2.0
rrow3p5 top3p4 top3p5 1.0
rcol3p5 bot2p5 bot3p5 1.0
r3p5 top3p5 bot3p5 2.0
rrow3p6 top3p5 top3p6 1.0
rcol3p6 bot2p6 bot3p6 1.0
r3p6 top3p6 bot3p6 2.0
rrow3p7 top3p6 top3p7 1.0
rcol3p7 bot2p7 bot3p7 1.0
r3p7 top3p7 bot3p7 2.0
rrow3p8 top3p7 top3p8 1.0
rcol3p8 bot2p8 bot3p8 1.0
r3p8 top3p8 bot3p8 2.0
rrow3p9 top3p8 top3p9 1.0
rcol3p9 bot2p9 bot3p9 1.0
r3p9 top3p9 bot3p9 2.0
rrow3p10 top3p9 top3p10 1.0
rcol3p10 bot2p10 bot3p10 1.0
r3p10 top3p10 bot3p10 2.0
rrow3p11 top3p10 top3p11 1.0
rcol3p11 bot2p11 bot3p11 1.0
r3p11 top3p11 bot3p11 2.0
rrow3p12 top3p11 top3p12 1.0
rcol3p12 bot2p12 bot3p12 1.0
r3p12 top3p12 bot3p12 2.0
rrow3p13 top3p12 top3p13 1.0
rcol3p13 bot2p13 bot3p13 1.0
r3p13 top3p13 bot3p13 2.0
rrow3p14 top3p13 top3p14 1.0
rcol3p14 bot2p14 bot3p14 1.0
r3p14 top3p14 bot3p14 2.0
rrow3p15 top3p14 top3p15 1.0
rcol3p15 bot2p15 bot3p15 1.0
r3p15 top3p15 bot3p15 2.0
rcol4p0 bot3p0 bot4p0 1.0
r4p0 top4p0 bot4p0 2.0
rrow4p1 top4p0 top4p1 1.0
rcol4p1 bot3p1 bot4p1 1.0
r4p1 top4p1 bot4p1 2.0
rrow4p2 top4p1 top4p2 1.0
rcol4p2 bot3p2 bot4p2 1.0
r4p2 top4p2 bot4p2 2.0
rrow4p3 top4p2 top4p3 1.0
rcol4p3 bot3p3 bot4p3 1.0
r4p3 top4p3 bot4p3 2.0
rrow4p4 top4p3 top4p4 1.0
rcol4p4 bot3p4 bot4p4 1.0
r4p4 top4p4 bot4p4 2.0
rrow4p5 top4p4 top4p5 1.0
rcol4p5 bot3p5 bot4p5 1.0
r4p5 top4p5 bot4p5 2.0
rrow4p6 top4p5 top4p6 1.0
rcol4p6 bot3p6 bot4p6 1.0
r4p6 top4p6 bot4p6 2.0
rrow4p7 top4p6 top4p7 1.0
rcol4p7 bot3p7 bot4p7 1.0
r4p7 top4p7 bot4p7 2.0
rrow4p8 top4p7 top4p8 1.0
rcol4p8 bot3p8 bot4p8 1.0
r4p8 top4p8 bot4p8 2.0
rrow4p9 top4p8 top4p9 1.0
rcol4p9 bot3p9 bot4p9 1.0
r4p9 top4p9 bot4p9 2.0
rrow4p10 top4p9 top4p10 1.0
rcol4p10 bot3p10 bot4p10 1.0
r4p10 top4p10 bot4p10 2.0
rrow4p11 top4p10 top4p11 1.0
rcol4p11 bot3p11 bot4p11 1.0
r4p11 top4p11 bot4p11 2.0
rrow4p12 top4p11 top4p12 1.0
rcol4p12 bot3p12 bot4p12 1.0
r4p12 top4p12 bot4p12 2.0
rrow4p13 top4p12 top4p13 1.0
rcol4p13 bot3p13 bot4p13 1.0
r4p13 top4p13 bot4p13 2.0
rrow4p14 top4p13 top4p14 1.0
rcol4p14 bot3p14 bot4p14 1.0
r4p14 top4p14 bot4p14 2.0
rrow4p15 top4p14 top4p15 1.0
rcol4p15 bot3p15 bot4p15 1.0
r4p15 top4p15 bot4p15 2.0
rcol5p0 bot4p0 bot5p0 1.0
r5p0 top5p0 bot5p0 2.0
rrow5p1 top5p0 top5p1 1.0
rcol5p1 bot4p1 bot5p1 1.0
r5p1 top5p1 bot5p1 2.0
rrow5p2 top5p1 top5p2 1.0
rcol5p2 bot4p2 bot5p2 1.0
r5p2 top5p2 bot5p2 2.0
rrow5p3 top5p2 top5p3 1.0
rcol5p3 bot4p3 bot5p3 1.0
r5p3 top5p3 bot5p3 2.0
rrow5p4 top5p3 top5p4 1.0
rcol5p4 bot4p4 bot5p4 1.0
r5p4 top5p4 bot5p4 2.0
rrow5p5 top5p4 top5p5 1.0
rcol5p5 bot4p5 bot5p5 1.0
r5p5 top5p5 bot5p5 2.0
rrow5p6 top5p5 top5p6 1.0
rcol5p6 bot4p6 bot5p6 1.0
r5p6 top5p6 bot5p6 2.0
rrow5p7 top5p6 top5p7 1.0
rcol5p7 bot4p7 bot5p7 1.0
r5p7 top5p7 bot5p7 2.0
rrow5p8 top5p7 top5p8 1.0
rcol5p8 bot4p8 bot5p8 1.0
r5p8 top5p8 bot5p8 2.0
rrow5p9 top5p8 top5p9 1.0
rcol5p9 bot4p9 bot5p9 1.0
r5p9 top5p9 bot5p9 2.0
rrow5p10 top5p9 top5p10 1.0
rcol5p10 bot4p10 bot5p10 1.0
r5p10 top5p10 bot5p10 2.0
rrow5p11 top5p10 top5p11 1.0
rcol5p11 bot4p11 bot5p11 1.0
r5p11 top5p11 bot5p11 2.0
rrow5p12 top5p11 top5p12 1.0
rcol5p12 bot4p12 bot5p12 1.0
r5p12 top5p12 bot5p12 2.0
rrow5p13 top5p12 top5p13 1.0
rcol5p13 bot4p13 bot5p13 1.0
r5p13 top5p13 bot5p13 2.0
rrow5p14 top5p13 top5p14 1.0
rcol5p14 bot4p14 bot5p14 1.0
r5p14 top5p14 bot5p14 2.0
rrow5p15 top5p14 top5p15 1.0
rcol5p15 bot4p15 bot5p15 1.0
r5p15 top5p15 bot5p15 2.0
rcol6p0 bot5p0 bot6p0 1.0
r6p0 top6p0 bot6p0 2.0
rrow6p1 top6p0 top6p1 1.0
rcol6p1 bot5p1 bot6p1 1.0
r6p1 top6p1 bot6p1 2.0
rrow6p2 top6p1 top6p2 1.0
rcol6p2 bot5p2 bot6p2 1.0
r6p2 top6p2 bot6p2 2.0
rrow6p3 top6p2 top6p3 1.0
rcol6p3 bot5p3 bot6p3 1.0
r6p3 top6p3 bot6p3 2.0
rrow6p4 top6p3 top6p4 1.0
rcol6p4 bot5p4 bot6p4 1.0
r6p4 top6p4 bot6p4 2.0
rrow6p5 top6p4 top6p5 1.0
rcol6p5 bot5p5 bot6p5 1.0
r6p5 top6p5 bot6p5 2.0
rrow6p6 top6p5 top6p6 1.0
rcol6p6 bot5p6 bot6p6 1.0
r6p6 top6p6 bot6p6 2.0
rrow6p7 top6p6 top6p7 1.0
rcol6p7 bot5p7 bot6p7 1.0
r6p7 top6p7 bot6p7 2.0
rrow6p8 top6p7 top6p8 1.0
rcol6p8 bot5p8 bot6p8 1.0
r6p8 top6p8 bot6p8 2.0
rrow6p9 top6p8 top6p9 1.0
rcol6p9 bot5p9 bot6p9 1.0
r6p9 top6p9 bot6p9 2.0
rrow6p10 top6p9 top6p10 1.0
rcol6p10 bot5p10 bot6p10 1.0
r6p10 top6p10 bot6p10 2.0
rrow6p11 top6p10 top6p11 1.0
rcol6p11 bot5p11 bot6p11 1.0
r6p11 top6p11 bot6p11 2.0
rrow6p12 top6p11 top6p12 1.0
rcol6p12 bot5p12 bot6p12 1.0
r6p12 top6p12 bot6p12 2.0
rrow6p13 top6p12 top6p13 1.0
rcol6p13 bot5p13 bot6p13 1.0
r6p13 top6p13 bot6p13 2.0
rrow6p14 top6p13 top6p14 1.0
rcol6p14 bot5p14 bot6p14 1.0
r6p14 top6p14 bot6p14 2.0
rrow6p15 top6p14 top6p15 1.0
rcol6p15 bot5p15 bot6p15 1.0
r6p15 top6p15 bot6p15 2.0
rcol7p0 bot6p0 bot7p0 1.0
r7p0 top7p0 bot7p0 2.0
rrow7p1 top7p0 top7p1 1.0
rcol7p1 bot6p1 bot7p1 1.0
r7p1 top7p1 bot7p1 2.0
rrow7p2 top7p1 top7p2 1.0
rcol7p2 bot6p2 bot7p2 1.0
r7p2 top7p2 bot7p2 2.0
rrow7p3 top7p2 top7p3 1.0
rcol7p3 bot6p3 bot7p3 1.0
r7p3 top7p3 bot7p3 2.0
rrow7p4 top7p3 top7p4 1.0
rcol7p4 bot6p4 bot7p4 1.0
r7p4 top7p4 bot7p4 2.0
rrow7p5 top7p4 top7p5 1.0
rcol7p5 bot6p5 bot7p5 1.0
r7p5 top7p5 bot7p5 2.0
rrow7p6 top7p5 top7p6 1.0
rcol7p6 bot6p6 bot7p6 1.0
r7p6 top7p6 bot7p6 2.0
rrow7p7 top7p6 top7p7 1.0
rcol7p7 bot6p7 bot7p7 1.0
r7p7 top7p7 bot7p7 2.0
rrow7p8 top7p7 top7p8 1.0
rcol7p8 bot6p8 bot7p8 1.0
r7p8 top7p8 bot7p8 2.0
rrow7p9 top7p8 top7p9 1.0
rcol7p9 bot6p9 bot7p9 1.0
r7p9 top7p9 bot7p9 2.0
rrow7p10 top7p9 top7p10 1.0
rcol7p10 bot6p10 bot7p10 1.0
r7p10 top7p10 bot7p10 2.0
rrow7p11 top7p10 top7p11 1.0
rcol7p11 bot6p11 bot7p11 1.0
r7p11 top7p11 bot7p11 2.0
rrow7p12 top7p11 top7p12 1.0
rcol7p12 bot6p12 bot7p12 1.0
r7p12 top7p12 bot7p12 2.0
rrow7p13 top7p12 top7p13 1.0
rcol7p13 bot6p13 bot7p13 1.0
r7p13 top7p13 bot7p13 2.0
rrow7p14 top7p13 top7p14 1.0
rcol7p14 bot6p14 bot7p14 1.0
r7p14 top7p14 bot7p14 2.0
rrow7p15 top7p14 top7p15 1.0
rcol7p15 bot6p15 bot7p15 1.0
r7p15 top7p15 bot7p15 2.0
rcol8p0 bot7p0 bot8p0 1.0
r8p0 top8p0 bot8p0 2.0
rrow8p1 top8p0 top8p1 1.0
rcol8p1 bot7p1 bot8p1 1.0
r8p1 top8p1 bot8p1 2.0
rrow8p2 top8p1 top8p2 1.0
rcol8p2 bot7p2 bot8p2 1.0
r8p2 top8p2 bot8p2 2.0
rrow8p3 top8p2 top8p3 1.0
rcol8p3 bot7p3 bot8p3 1.0
r8p3 top8p3 bot8p3 2.0
rrow8p4 top8p3 top8p4 1.0
rcol8p4 bot7p4 bot8p4 1.0
r8p4 top8p4 bot8p4 2.0
rrow8p5 top8p4 top8p5 1.0
rcol8p5 bot7p5 bot8p5 1.0
r8p5 top8p5 bot8p5 2.0
rrow8p6 top8p5 top8p6 1.0
rcol8p6 bot7p6 bot8p6 1.0
r8p6 top8p6 bot8p6 2.0
rrow8p7 top8p6 top8p7 1.0
rcol8p7 bot7p7 bot8p7 1.0
r8p7 top8p7 bot8p7 2.0
rrow8p8 top8p7 top8p8 1.0
rcol8p8 bot7p8 bot8p8 1.0
r8p8 top8p8 bot8p8 2.0
rrow8p9 top8p8 top8p9 1.0
rcol8p9 bot7p9 bot8p9 1.0
r8p9 top8p9 bot8p9 2.0
rrow8p10 top8p9 top8p10 1.0
rcol8p10 bot7p10 bot8p10 1.0
r8p10 top8p10 bot8p10 2.0
rrow8p11 top8p10 top8p11 1.0
rcol8p11 bot7p11 bot8p11 1.0
r8p11 top8p11 bot8p11 2.0
rrow8p12 top8p11 top8p12 1.0
rcol8p12 bot7p12 bot8p12 1.0
r8p12 top8p12 bot8p12 2.0
rrow8p13 top8p12 top8p13 1.0
rcol8p13 bot7p13 bot8p13 1.0
r8p13 top8p13 bot8p13 2.0
rrow8p14 top8p13 top8p14 1.0
rcol8p14 bot7p14 bot8p14 1.0
r8p14 top8p14 bot8p14 2.0
rrow8p15 top8p14 top8p15 1.0
rcol8p15 bot7p15 bot8p15 1.0
r8p15 top8p15 bot8p15 2.0
rcol9p0 bot8p0 bot9p0 1.0
r9p0 top9p0 bot9p0 2.0
rrow9p1 top9p0 top9p1 1.0
rcol9p1 bot8p1 bot9p1 1.0
r9p1 top9p1 bot9p1 2.0
rrow9p2 top9p1 top9p2 1.0
rcol9p2 bot8p2 bot9p2 1.0
r9p2 top9p2 bot9p2 2.0
rrow9p3 top9p2 top9p3 1.0
rcol9p3 bot8p3 bot9p3 1.0
r9p3 top9p3 bot9p3 2.0
rrow9p4 top9p3 top9p4 1.0
rcol9p4 bot8p4 bot9p4 1.0
r9p4 top9p4 bot9p4 2.0
rrow9p5 top9p4 top9p5 1.0
rcol9p5 bot8p5 bot9p5 1.0
r9p5 top9p5 bot9p5 2.0
rrow9p6 top9p5 top9p6 1.0
rcol9p6 bot8p6 bot9p6 1.0
r9p6 top9p6 bot9p6 2.0
rrow9p7 top9p6 top9p7 1.0
rcol9p7 bot8p7 bot9p7 1.0
r9p7 top9p7 bot9p7 2.0
rrow9p8 top9p7 top9p8 1.0
rcol9p8 bot8p8 bot9p8 1.0
r9p8 top9p8 bot9p8 2.0
rrow9p9 top9p8 top9p9 1.0
rcol9p9 bot8p9 bot9p9 1.0
r9p9 top9p9 bot9p9 2.0
rrow9p10 top9p9 top9p10 1.0
rcol9p10 bot8p10 bot9p10 1.0
r9p10 top9p10 bot9p10 2.0
rrow9p11 top9p10 top9p11 1.0
rcol9p11 bot8p11 bot9p11 1.0
r9p11 top9p11 bot9p11 2.0
rrow9p12 top9p11 top9p12 1.0
rcol9p12 bot8p12 bot9p12 1.0
r9p12 top9p12 bot9p12 2.0
rrow9p13 top9p12 top9p13 1.0
rcol9p13 bot8p13 bot9p13 1.0
r9p13 top9p13 bot9p13 2.0
rrow9p14 top9p13 top9p14 1.0
rcol9p14 bot8p14 bot9p14 1.0
r9p14 top9p14 bot9p14 2.0
rrow9p15 top9p14 top9p15 1.0
rcol9p15 bot8p15 bot9p15 1.0
r9p15 top9p15 bot9p15 2.0
rcol10p0 bot9p0 bot10p0 1.0
r10p0 top10p0 bot10p0 2.0
rrow10p1 top10p0 top10p1 1.0
rcol10p1 bot9p1 bot10p1 1.0
r10p1 top10p1 bot10p1 2.0
rrow10p2 top10p1 top10p2 1.0
rcol10p2 bot9p2 bot10p2 1.0
r10p2 top10p2 bot10p2 2.0
rrow10p3 top10p2 top10p3 1.0
rcol10p3 bot9p3 bot10p3 1.0
r10p3 top10p3 bot10p3 2.0
rrow10p4 top10p3 top10p4 1.0
rcol10p4 bot9p4 bot10p4 1.0
r10p4 top10p4 bot10p4 2.0
rrow10p5 top10p4 top10p5 1.0
rcol10p5 bot9p5 bot10p5 1.0
r10p5 top10p5 bot10p5 2.0
rrow10p6 top10p5 top10p6 1.0
rcol10p6 bot9p6 bot10p6 1.0
r10p6 top10p6 bot10p6 2.0
rrow10p7 top10p6 top10p7 1.0
rcol10p7 bot9p7 bot10p7 1.0
r10p7 top10p7 bot10p7 2.0
rrow10p8 top10p7 top10p8 1.0
rcol10p8 bot9p8 bot10p8 1.0
r10p8 top10p8 bot10p8 2.0
rrow10p9 top10p8 top10p9 1.0
rcol10p9 bot9p9 bot10p9 1.0
r10p9 top10p9 bot10p9 2.0
rrow10p10 top10p9 top10p10 1.0
rcol10p10 bot9p10 bot10p10 1.0
r10p10 top10p10 bot10p10 2.0
rrow10p11 top10p10 top10p11 1.0
rcol10p11 bot9p11 bot10p11 1.0
r10p11 top10p11 bot10p11 2.0
rrow10p12 top10p11 top10p12 1.0
rcol10p12 bot9p12 bot10p12 1.0
r10p12 top10p12 bot10p12 2.0
rrow10p13 top10p12 top10p13 1.0
rcol10p13 bot9p13 bot10p13 1.0
r10p13 top10p13 bot10p13 2.0
rrow10p14 top10p13 top10p14 1.0
rcol10p14 bot9p14 bot10p14 1.0
r10p14 top10p14 bot10p14 2.0
rrow10p15 top10p14 top10p15 1.0
rcol10p15 bot9p15 bot10p15 1.0
r10p15 top10p15 bot10p15 2.0
rcol11p0 bot10p0 bot11p0 1.0
r11p0 top11p0 bot11p0 2.0
rrow11p1 top11p0 top11p1 1.0
rcol11p1 bot10p1 bot11p1 1.0
r11p1 top11p1 bot11p1 2.0
rrow11p2 top11p1 top11p2 1.0
rcol11p2 bot10p2 bot11p2 1.0
r11p2 top11p2 bot11p2 2.0
rrow11p3 top11p2 top11p3 1.0
rcol11p3 bot10p3 bot11p3 1.0
r11p3 top11p3 bot11p3 2.0
rrow11p4 top11p3 top11p4 1.0
rcol11p4 bot10p4 bot11p4 1.0
r11p4 top11p4 bot11p4 2.0
rrow11p5 top11p4 top11p5 1.0
rcol11p5 bot10p5 bot11p5 1.0
r11p5 top11p5 bot11p5 2.0
rrow11p6 top11p5 top11p6 1.0
rcol11p6 bot10p6 bot11p6 1.0
r11p6 top11p6 bot11p6 2.0
rrow11p7 top11p6 top11p7 1.0
rcol11p7 bot10p7 bot11p7 1.0
r11p7 top11p7 bot11p7 2.0
rrow11p8 top11p7 top11p8 1.0
rcol11p8 bot10p8 bot11p8 1.0
r11p8 top11p8 bot11p8 2.0
rrow11p9 top11p8 top11p9 1.0
rcol11p9 bot10p9 bot11p9 1.0
r11p9 top11p9 bot11p9 2.0
rrow11p10 top11p9 top11p10 1.0
rcol11p10 bot10p10 bot11p10 1.0
r11p10 top11p10 bot11p10 2.0
rrow11p11 top11p10 top11p11 1.0
rcol11p11 bot10p11 bot11p11 1.0
r11p11 top11p11 bot11p11 2.0
rrow11p12 top11p11 top11p12 1.0
rcol11p12 bot10p12 bot11p12 1.0
r11p12 top11p12 bot11p12 2.0
rrow11p13 top11p12 top11p13 1.0
rcol11p13 bot10p13 bot11p13 1.0
r11p13 top11p13 bot11p13 2.0
rrow11p14 top11p13 top11p14 1.0
rcol11p14 bot10p14 bot11p14 1.0
r11p14 top11p14 bot11p14 2.0
rrow11p15 top11p14 top11p15 1.0
rcol11p15 bot10p15 bot11p15 1.0
r11p15 top11p15 bot11p15 2.0
rcol12p0 bot11p0 bot12p0 1.0
r12p0 top12p0 bot12p0 2.0
rrow12p1 top12p0 top12p1 1.0
rcol12p1 bot11p1 bot12p1 1.0
r12p1 top12p1 bot12p1 2.0
rrow12p2 top12p1 top12p2 1.0
rcol12p2 bot11p2 bot12p2 1.0
r12p2 top12p2 bot12p2 2.0
rrow12p3 top12p2 top12p3 1.0
rcol12p3 bot11p3 bot12p3 1.0
r12p3 top12p3 bot12p3 2.0
rrow12p4 top12p3 top12p4 1.0
rcol12p4 bot11p4 bot12p4 1.0
r12p4 top12p4 bot12p4 2.0
rrow12p5 top12p4 top12p5 1.0
rcol12p5 bot11p5 bot12p5 1.0
r12p5 top12p5 bot12p5 2.0
rrow12p6 top12p5 top12p6 1.0
rcol12p6 bot11p6 bot12p6 1.0
r12p6 top12p6 bot12p6 2.0
rrow12p7 top12p6 top12p7 1.0
rcol12p7 bot11p7 bot12p7 1.0
r12p7 top12p7 bot12p7 2.0
rrow12p8 top12p7 top12p8 1.0
rcol12p8 bot11p8 bot12p8 1.0
r12p8 top12p8 bot12p8 2.0
rrow12p9 top12p8 top12p9 1.0
rcol12p9 bot11p9 bot12p9 1.0
r12p9 top12p9 bot12p9 2.0
rrow12p10 top12p9 top12p10 1.0
rcol12p10 bot11p10 bot12p10 1.0
r12p10 top12p10 bot12p10 2.0
rrow12p11 top12p10 top12p11 1.0
rcol12p11 bot11p11 bot12p11 1.0
r12p11 top12p11 bot12p11 2.0
rrow12p12 top12p11 top12p12 1.0
rcol12p12 bot11p12 bot12p12 1.0
r12p12 top12p12 bot12p12 2.0
rrow12p13 top12p12 top12p13 1.0
rcol12p13 bot11p13 bot12p13 1.0
r12p13 top12p13 bot12p13 2.0
rrow12p14 top12p13 top12p14 1.0
rcol12p14 bot11p14 bot12p14 1.0
r12p14 top12p14 bot12p14 2.0
rrow12p15 top12p14 top12p15 1.0
rcol12p15 bot11p15 bot12p15 1.0
r12p15 top12p15 bot12p15 2.0
rcol13p0 bot12p0 bot13p0 1.0
r13p0 top13p0 bot13p0 2.0
rrow13p1 top13p0 top13p1 1.0
rcol13p1 bot12p1 bot13p1 1.0
r13p1 top13p1 bot13p1 2.0
rrow13p2 top13p1 top13p2 1.0
rcol13p2 bot12p2 bot13p2 1.0
r13p2 top13p2 bot13p2 2.0
rrow13p3 top13p2 top13p3 1.0
rcol13p3 bot12p3 bot13p3 1.0
r13p3 top13p3 bot13p3 2.0
rrow13p4 top13p3 top13p4 1.0
rcol13p4 bot12p4 bot13p4 1.0
r13p4 top13p4 bot13p4 2.0
rrow13p5 top13p4 top13p5 1.0
rcol13p5 bot12p5 bot13p5 1.0
r13p5 top13p5 bot13p5 2.0
rrow13p6 top13p5 top13p6 1.0
rcol13p6 bot12p6 bot13p6 1.0
r13p6 top13p6 bot13p6 2.0
rrow13p7 top13p6 top13p7 1.0
rcol13p7 bot12p7 bot13p7 1.0
r13p7 top13p7 bot13p7 2.0
rrow13p8 top13p7 top13p8 1.0
rcol13p8 bot12p8 bot13p8 1.0
r13p8 top13p8 bot13p8 2.0
rrow13p9 top13p8 top13p9 1.0
rcol13p9 bot12p9 bot13p9 1.0
r13p9 top13p9 bot13p9 2.0
rrow13p10 top13p9 top13p10 1.0
rcol13p10 bot12p10 bot13p10 1.0
r13p10 top13p10 bot13p10 2.0
rrow13p11 top13p10 top13p11 1.0
rcol13p11 bot12p11 bot13p11 1.0
r13p11 top13p11 bot13p11 2.0
rrow13p12 top13p11 top13p12 1.0
rcol13p12 bot12p12 bot13p12 1.0
r13p12 top13p12 bot13p12 2.0
rrow13p13 top13p12 top13p13 1.0
rcol13p13 bot12p13 bot13p13 1.0
r13p13 top13p13 bot13p13 2.0
rrow13p14 top13p13 top13p14 1.0
rcol13p14 bot12p14 bot13p14 1.0
r13p14 top13p14 bot13p14 2.0
rrow13p15 top13p14 top13p15 1.0
rcol13p15 bot12p15 bot13p15 1.0
r13p15 top13p15 bot13p15 2.0
rcol14p0 bot13p0 bot14p0 1.0
r14p0 top14p0 bot14p0 2.0
rrow14p1 top14p0 top14p1 1.0
rcol14p1 bot13p1 bot14p1 1.0
r14p1 top14p1 bot14p1 2.0
rrow14p2 top14p1 top14p2 1.0
rcol14p2 bot13p2 bot14p2 1.0
r14p2 top14p2 bot14p2 2.0
rrow14p3 top14p2 top14p3 1.0
rcol14p3 bot13p3 bot14p3 1.0
r14p3 top14p3 bot14p3 2.0
rrow14p4 top14p3 top14p4 1.0
rcol14p4 bot13p4 bot14p4 1.0
r14p4 top14p4 bot14p4 2.0
rrow14p5 top14p4 top14p5 1.0
rcol14p5 bot13p5 bot14p5 1.0
r14p5 top14p5 bot14p5 2.0
rrow14p6 top14p5 top14p6 1.0
rcol14p6 bot13p6 bot14p6 1.0
r14p6 top14p6 bot14p6 2.0
rrow14p7 top14p6 top14p7 1.0
rcol14p7 bot13p7 bot14p7 1.0
r14p7 top14p7 bot14p7 2.0
rrow14p8 top14p7 top14p8 1.0
rcol14p8 bot13p8 bot14p8 1.0
r14p8 top14p8 bot14p8 2.0
rrow14p9 top14p8 top14p9 1.0
rcol14p9 bot13p9 bot14p9 1.0
r14p9 top14p9 bot14p9 2.0
rrow14p10 top14p9 top14p10 1.0
rcol14p10 bot13p10 bot14p10 1.0
r14p10 top14p10 bot14p10 2.0
rrow14p11 top14p10 top14p11 1.0
rcol14p11 bot13p11 bot14p11 1.0
r14p11 top14p11 bot14p11 2.0
rrow14p12 top14p11 top14p12 1.0
rcol14p12 bot13p12 bot14p12 1.0
r14p12 top14p12 bot14p12 2.0
rrow14p13 top14p12 top14p13 1.0
rcol14p13 bot13p13 bot14p13 1.0
r14p13 top14p13 bot14p13 2.0
rrow14p14 top14p13 top14p14 1.0
rcol14p14 bot13p14 bot14p14 1.0
r14p14 top14p14 bot14p14 2.0
rrow14p15 top14p14 top14p15 1.0
rcol14p15 bot13p15 bot14p15 1.0
r14p15 top14p15 bot14p15 2.0
rcol15p0 bot14p0 bot15p0 1.0
r15p0 top15p0 bot15p0 2.0
rrow15p1 top15p0 top15p1 1.0
rcol15p1 bot14p1 bot15p1 1.0
r15p1 top15p1 bot15p1 2.0
rrow15p2 top15p1 top15p2 1.0
rcol15p2 bot14p2 bot15p2 1.0
r15p2 top15p2 bot15p2 2.0
rrow15p3 top15p2 top15p3 1.0
rcol15p3 bot14p3 bot15p3 1.0
r15p3 top15p3 bot15p3 2.0
rrow15p4 top15p3 top15p4 1.0
rcol15p4 bot14p4 bot15p4 1.0
r15p4 top15p4 bot15p4 2.0
rrow15p5 top15p4 top15p5 1.0
rcol15p5 bot14p5 bot15p5 1.0
r15p5 top15p5 bot15p5 2.0
rrow15p6 top15p5 top15p6 1.0
rcol15p6 bot14p6 bot15p6 1.0
r15p6 top15p6 bot15p6 2.0
rrow15p7 top15p6 top15p7 1.0
rcol15p7 bot14p7 bot15p7 1.0
r15p7 top15p7 bot15p7 2.0
rrow15p8 top15p7 top15p8 1.0
rcol15p8 bot14p8 bot15p8 1.0
r15p8 top15p8 bot15p8 2.0
rrow15p9 top15p8 top15p9 1.0
rcol15p9 bot14p9 bot15p9 1.0
r15p9 top15p9 bot15p9 2.0
rrow15p10 top15p9 top15p10 1.0
rcol15p10 bot14p10 bot15p10 1.0
r15p10 top15p10 bot15p10 2.0
rrow15p11 top15p10 top15p11 1.0
rcol15p11 bot14p11 bot15p11 1.0
r15p11 top15p11 bot15p11 2.0
rrow15p12 top15p11 top15p12 1.0
rcol15p12 bot14p12 bot15p12 1.0
r15p12 top15p12 bot15p12 2.0
rrow15p13 top15p12 top15p13 1.0
rcol15p13 bot14p13 bot15p13 1.0
r15p13 top15p13 bot15p13 2.0
rrow15p14 top15p13 top15p14 1.0
rcol15p14 bot14p14 bot15p14 1.0
r15p14 top15p14 bot15p14 2.0
rrow15p15 top15p14 top15p15 1.0
rcol15p15 bot14p15 bot15p15 1.0
r15p15 top15p15 bot15p15 2.0
rout0 0 bot15p0 0.5
rout1 0 bot15p1 0.5
rout2 0 bot15p2 0.5
rout3 0 bot15p3 0.5
rout4 0 bot15p4 0.5
rout5 0 bot15p5 0.5
rout6 0 bot15p6 0.5
rout7 0 bot15p7 0.5
rout8 0 bot15p8 0.5
rout9 0 bot15p9 0.5
rout10 0 bot15p10 0.5
rout11 0 bot15p11 0.5
rout12 0 bot15p12 0.5
rout13 0 bot15p13 0.5
rout14 0 bot15p14 0.5
rout15 0 bot15p15 0.5

.print OP i(rout0) i(rout1) i(rout2) i(rout3) i(rout4) i(rout5) i(rout6) i(rout7) i(rout8) i(rout9) i(rout10) i(rout11) i(rout12) i(rout13) i(rout14) i(rout15)
.end
